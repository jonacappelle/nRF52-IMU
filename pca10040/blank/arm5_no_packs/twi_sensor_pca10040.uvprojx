# Keil uVision project twi_sensor_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192 NDEBUG INV_MSG_ENABLE
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config;..\Invn;..\arm5_no_packs;..\..\blank;..\Invn;..\Invn\Devices;..\Invn\Devices\Drivers;..\Invn\Devices\Drivers\Icm20948;..\Invn\DynamicProtocol;..\Invn\EmbUtils;..\Invn\Images;..\Invn\VSensor;\
  asm define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_twi.c nrf_drv_uart.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c nrfx_timer.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group IMU
    ./: imu.c
    ../Invn/: IDDVersion.h InvBool.h InvError.h InvExport.h
    ../Invn/VSensor/: VSensor.c VSensor.h VSensorData.h VSensorConfig.h VSensorEvent.h VSensorId.h VSensorListener.h VSensorSmartListener.h VSensorType.h VSensorVersion.h
    ../Invn/Images/: icm20948_img.dmp3a.h icm20948_img.h
    ../Invn/EmbUtils/: CBinaryReader.h CBinaryWriter.h DataConverter.c DataConverter.h ErrorHelper.c ErrorHelper.h InvAssert.h InvBasicMath.c InvBasicMath.h InvBits.h InvCksum.c InvCksum.h InvFormat.c InvFormat.h InvList.c InvList.h InvPrintf.c InvPrintf.h InvProtocol.c InvProtocol.h InvQueue.c InvQueue.h InvScheduler.c InvScheduler.h InvString.h Logger.c Logger.h Message.c Message.h RingBuffer.h RingByteBuffer.c RingByteBuffer.h UartTxEmulator.c UartTxEmulator.h
    ../Invn/DynamicProtocol/: DynProtocol.c DynProtocol.h DynProtocolTransport.h DynProtocolTransportUart.c DynProtocolTransportUart.h
    ../Invn/Devices/: Device.h DeviceIcm20948.c DeviceIcm20948.h HostSerif.c HostSerif.h Sensor.c SensorConfig.h SensorTypes.h SerifHal.h VSensorId.c
    ../Invn/Devices/Drivers/Icm20948/: Icm20948.h Icm20948Augmented.c Icm20948Augmented.h Icm20948AuxCompassAkm.c Icm20948AuxCompassAkm.h Icm20948AuxTransport.c Icm20948AuxTransport.h Icm20948DataBaseControl.c Icm20948DataBaseControl.h Icm20948DataBaseDriver.c Icm20948DataBaseDriver.h Icm20948DataConverter.c Icm20948DataConverter.h Icm20948Defs.h Icm20948Dmp3Driver.c Icm20948Dmp3Driver.h Icm20948LoadFirmware.c Icm20948LoadFirmware.h Icm20948MPUFifoControl.c Icm20948MPUFifoControl.h Icm20948SelfTest.c Icm20948SelfTest.h Icm20948Serif.h Icm20948Setup.c Icm20948Setup.h Icm20948Transport.c Icm20948Transport.h
  group TWI
    ./: usr_twi.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
